Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (2)\R&D\Producttekeningen\2. HOUTBETON VOORZIENINGEN (wood concrete)\VOGELS EXTERN (bird boxes external)\BZP1-HZP1\HZP1 brontekeningen\HZP1-01.IFC
Time: 2026-05-28T10:45:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
